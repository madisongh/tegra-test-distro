VOLATILE_BINDS = ""
do_install() {
    :
}
ALLOW_EMPTY_${PN} = "1"
