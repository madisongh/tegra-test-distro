RPROVIDES_${PN}_remove = "u-boot-default-env"

