PACKAGECONFIG:append_cuda = " dnn"
