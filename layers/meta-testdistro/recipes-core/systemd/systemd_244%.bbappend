FILESEXTRAPATHS_prepend := "${THISDIR}/systemd-244:"
SRC_URI += "file://0001-makefs-strdup-arguments-to-mkfs.patch"

