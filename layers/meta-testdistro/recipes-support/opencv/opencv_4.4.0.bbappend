PACKAGECONFIG_append_cuda = " dnn"
