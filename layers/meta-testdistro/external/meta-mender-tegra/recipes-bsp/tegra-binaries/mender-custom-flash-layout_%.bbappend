FILESEXTRAPATHS_prepend := "${THISDIR}/mender-custom-flash-layout:"
