SRC_REPO = "github.com/madisongh/mender.git;protocol=https"
SRC_URI = "git://${SRC_REPO};branch=patches-2.6.0"
SRCREV = "2c1d5e94bd550971edb7a371f270a0fbf293d4fe"
PV .= "+git${SRCPV}"
