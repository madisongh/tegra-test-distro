RDEPENDS_${PN}_remove_tegra186 = "tegra-redundant-boot"
RDEPENDS_${PN}_remove_tegra194 = "tegra-redundant-boot"
RDEPENDS_${PN}_append_tegra186 = " tegra-boot-tools-updater"
RDEPENDS_${PN}_append_tegra194 = " tegra-boot-tools-updater"

