# XXX already upstream with busybox 1.33
SRC_URI_remove = "file://0001-mount-support-the-sizelimit-and-offset-option-for-lo.patch"
