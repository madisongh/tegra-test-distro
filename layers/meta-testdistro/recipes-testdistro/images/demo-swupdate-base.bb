require swupdate-common.inc
