RDEPENDS_${PN} += "argus-samples"
