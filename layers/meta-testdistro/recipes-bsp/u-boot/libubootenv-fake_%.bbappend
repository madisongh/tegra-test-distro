RREPLACES_${PN} = "libubootenv-bin"
PROVIDES += "libubootenv"
