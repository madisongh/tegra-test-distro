require td-linux-tegra.inc
