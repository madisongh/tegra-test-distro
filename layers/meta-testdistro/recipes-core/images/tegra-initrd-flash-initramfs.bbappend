IMAGE_ROOTFS_SIZE:forcevariable = "32768"
IMAGE_ROOTFS_EXTRA_SPACE = "0"
