FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0007-Add-adsp-fw-to-BUP-payload.patch"

