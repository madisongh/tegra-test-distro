EXTRA_OECMAKE_append_tegra = "-DBUILD_GLSL_EXTENSIONS:BOOL=OFF"
