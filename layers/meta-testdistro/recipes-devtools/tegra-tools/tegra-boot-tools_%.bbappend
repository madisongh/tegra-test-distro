EXTRA_OECONF_append_secureboot = " --with-extended-sector-count=511"
PACKAGE_ARCH_secureboot = "${MACHINE_ARCH}"
