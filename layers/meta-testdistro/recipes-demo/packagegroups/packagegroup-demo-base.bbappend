RDEPENDS:${PN} += " \
    fuse3 \
    gdb \
    gdbserver \
"
