SRC_REPO = "github.com/madisongh/mender.git;protocol=https"
SRC_URI = "git://${SRC_REPO};branch=patches-2.6.1"
SRCREV = "fd49156869690f2d12cb6a8a94a240a578177a6b"
PV .= "+git${SRCPV}"
