../../meta-tegrademo/classes/mender-workarounds.bbclass